# Repository banksh/ProxBand

## KiCad design rf/rf.kicad_pcb

Parts:
C1, C2: 3.3pF; 0402
C3: 10pF; 0402
C4: 4.7uF; 0603
C5: 1nF; 0201
C6: 33pF; SM0402_c
C7: 22pF; SM0402_c
C8: 10nF; SM0402_c
C9, C11, C17: 100pF; SM0402_c
C10: 56pF; SM0402_c
C12: 10uF; SM0402_c
C13, C16, C18, C19, C20, C21, C23, C24, C25, C26: 220nF; SM0402_c
C14: 2.7pF; SM0402_c
C15: 1.2pF; SM0402_c
C22: 150nF; SM0402_c
L1, L3: 6.8nH; SM0402
L2: 3nH; SM0402
L4: 1.3nH; SM0402
L5, L7: 3.3nH; SM0402
L6: 4.7nH; SM0402
L8: 6.2nH; SM0402
L9: 12nH; SM0402
L10: 47nH; SM0603
P1: CONN_1
P2: CONN_7
R1, R2: 50; SM0402_r
R3: 36k; SM0402_r
R4: 100K; SM0402_r
U1: SE2435L
U2: ADF7023
X1: CRYSTAL; crystal_FA238-TSX3225

Connections:
GND: C1.2, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.2, C9.2, C11.2, C12.1, C13.2, C15.2, C16.1, C17.1, C18.2, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, P2.7, R1.1, R2.2, R3.2, R4.2, U1.7 (ANT_SEL), U1.8 (GND), U1.10 (NC), U1.13 (NC), U1.15 (NC), U1.17 (NC), U1.18 (NC), U1.25 (PAD), U2.33 (EPAD)
unnamed: U1.4 (CTX), U2.17 (GP0)
unnamed: U1.3 (CPS), U2.18 (GP1)
unnamed: C9.1, L7.2, U1.24 (VCC1)
unnamed: C7.2, L6.2, U1.23 (VCC0)
unnamed: C22.2, U2.12 (CWAKEUP)
unnamed: L3.2, U1.14 (ANT1)
unnamed: U1.1 (CSD), U2.19 (GP2)
unnamed: L1.1, P1.1
unnamed: P2.6, U2.20 (IRQ_GP3)
unnamed: P2.2, R4.1, U2.24 (~CS)
unnamed: P2.3, U2.23 (MOSI)
unnamed: P2.4, U2.22 (SCLK)
unnamed: P2.5, U2.21 (MISO)
unnamed: C21.2, U2.11 (CREGSYNTH)
unnamed: C1.1, L1.2, L3.1
unnamed: C19.2, U2.32 (ADCVREF)
unnamed: C25.2, U2.26 (CREGDIG2)
unnamed: C26.2, U2.15 (DGUARD), U2.16 (CREGDIG1)
unnamed: C14.2, L8.2, U2.4 (RFIO_1P)
unnamed: L10.1, U1.2 (PA_IN), U2.6 (RFO2)
unnamed: C13.1, L10.2, U2.3 (CREGRF2)
unnamed: R3.1, U2.2 (RBIAS)
unnamed: U1.9 (LNA_IN), U1.11 (RX_FLT)
unnamed: L4.1, U1.20 (PA_OUT)
unnamed: C10.1, U1.6 (TR)
unnamed: C3.2, L2.1, L4.2
unnamed: C2.2, L2.2, U1.16 (TX_IN)
unnamed: L5.2, U1.21 (VCC2)
unnamed: R2.1, U1.5 (TX_FL)
unnamed: C15.1, L9.2, U2.5 (RFIO_1N)
unnamed: C20.2, U2.9 (CREGVCO), U2.10 (VCOGUARD)
unnamed: C18.1, U2.1 (CREGRF1)
unnamed: C10.2, C14.1, L9.1
unnamed: C11.1, L8.1
unnamed: C24.2, U2.14 (XOSC26N), X1.2
unnamed: R1.2, U1.12 (ANT2)
unnamed: C23.2, U2.13 (XOSC26P), X1.1
VDD: C4.2, C5.2, C6.2, C8.1, C12.2, C16.2, C17.2, L5.1, L6.1, L7.1, P2.1, U2.7 (VDDBAT2), U2.29 (VDDBAT1)

Board: 2 copper layers, 27.1 x 16.9 mm, 45 parts (7 on the bottom side), 39 nets.

## KiCad design Main.kicad_pcb

Parts:
C1: 18pF
C2, C13, C15: 22pF
C3, C37, C41: 2.2uF
C4, C44, C51: 4.7uF
C5, C12, C14, C16, C17, C18, C19, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C33, C34, C35, C38, C40, C52: 100nF
C6, C7: 12.5pF
C8, C42: 10nF
C11, C39, C47: 10uF
C20, C36: 1uF
C21: 47pF
C32: 4n7
C43, C45, C46, C48, C49, C50: .1uF
CON1: USB-MINI-B
D1, D2: LED
L1, L2: INDUCTOR
L3: 10uH
P1: CONN_6
P2: CONN_2
R1, R2, R3, R5, R6, R7, R10, R11, R12, R13, R14: 10K
R4: 1M
R8, R9: 68
R15: 2K
SW1, SW2: TACT
U1: AS4C8M16S
U2: M10478
U3: LM3670
U4: XBEE
U5: STM32F429_144
U6: MPL3115A2; MODULE
U7: MPU-9250; MODULE
U8: RT9169
U9: MCP7383X; MODULE
U10: N25Q128A
U11: FPC_50
X1: 32.768MHz
X2: 8MHz

Connections:
+1.8V: C2.1, C3.1, C11.1, L3.2, U2.8 (VCC), U3.4 (FB)
+5V: C51.1, CON1.1 (VBUS), U9.4
+BATT: C4.1, C44.1, C46.1, P2.2 (PM), R5.1, U3.1 (Vin), U8.3 (VI), U9.3
/A0: U1.23 (A0), U5.10 (PF0)
/A1: U1.24 (A1), U5.11 (PF1)
/A2: U1.25 (A2), U5.12 (PF2)
/A3: U1.26 (A3), U5.13 (PF3)
/A4: U1.29 (A4), U5.14 (PF4)
/A5: U1.30 (A5), U5.15 (PF5)
/A6: U1.31 (A6), U5.50 (PF12)
/A7: U1.32 (A7), U5.53 (PF13)
/A8: U1.33 (A8), U5.54 (PF14)
/A9: U1.34 (A9), U5.55 (PF15)
/A10: U1.22 (A10/AP), U5.56 (PG0)
/A11: U1.35 (A11), U5.57 (PG1)
/ANT_IN: C1.2, L2.2, U2.6 (ANT_IN)
/ANT_OUT: C1.1, L1.2, U2.4 (ANT_OUT)
/B2: U5.122 (PD6), U11.32 (DB0)
/B3: U5.126 (PG11), U11.31 (DB1)
/B4: U5.127 (PG12), U11.30 (DB2)
/B5: U5.37 (PA3), U11.29 (DB3)
/B6: U5.139 (PB8), U11.28 (DB4)
/B7: U5.140 (PB9), U11.27 (DB5)
/BA0: U1.20 (BA0), U5.89 (PG4)
/BA1: U1.21 (BA1), U5.90 (PG5)
/BARO_INT: U5.73 (PB12), U6.6 (INT1)
/BARO_SCL: U6.8 (SCL), U7.7 (AUX_CL)
/BARO_SDA: U6.7 (SDA), U7.21 (AUX_DA)
/BAT_DRIVE: R6.2, U5.20 (PF8)
/BAT_SENSE: R5.2, R6.1, U5.18 (PF6)
/BUCK_EN: C5.1, U3.3 (EN), U5.5 (PE6)
/CHARGE_STAT: U5.110 (PA15), U9.1
/CSX: U5.28 (PC2), U11.38 (CSX)
/D0: U1.2 (DQ0), U5.85 (PD14)
/D1: U1.4 (DQ1), U5.86 (PD15)
/D2: U1.5 (DQ2), U5.114 (PD0)
/D3: U1.7 (DQ3), U5.115 (PD1)
/D4: U1.8 (DQ4), U5.58 (PE7)
/D5: U1.10 (DQ5), U5.59 (PE8)
/D6: U1.11 (DQ6), U5.60 (PE9)
/D7: U1.13 (DQ7), U5.63 (PE10)
/D8: U1.42 (DQ8), U5.64 (PE11)
/D9: U1.44 (DQ9), U5.65 (PE12)
/D10: U1.45 (DQ10), U5.66 (PE13)
/D11: U1.47 (DQ11), U5.67 (PE14)
/D12: U1.48 (DQ12), U5.68 (PE15)
/D13: U1.50 (DQ13), U5.77 (PD8)
/D14: U1.51 (DQ14), U5.78 (PD9)
/D15: U1.53 (DQ15), U5.79 (PD10)
/DCX_SCL: U5.19 (PF7), U11.37 (D/CX(SCL))
/DOTCLK: U5.92 (PG7), U11.13 (DOTCLK)
/FL_CS: U5.88 (PG3), U10.1 (S#)
/FL_HOLD: U5.98 (PC8), U10.7 (HOLD#/DQ3)
/FL_MISO: U5.134 (PB4), U10.2 (DQ1)
/FL_MOSI: U5.43 (PA7), U10.5 (DQ0)
/FL_SCK: U5.41 (PA5), U10.6 (C)
/FL_WP: U5.87 (PG2), U10.3 (W#/Vpp/DQ2)
/G2: U5.42 (PA6), U11.26 (DB6)
/G3: U5.125 (PG10), U11.25 (DB7)
/G4: U5.69 (PB10), U11.24 (DB8)
/G5: U5.70 (PB11), U11.23 (DB9)
/G6: U5.97 (PC7), U11.22 (DB10)
/G7: U5.117 (PD3), U11.21 (DB11)
/GPS_CTS: R3.2, U2.23 (CLK_CTS)
/GPS_ONOFF: U2.26 (ON_OFF), U5.1 (PE2)
/GPS_RX: C13.1, U2.21 (RX), U5.35 (PA1)
/GPS_TX: C15.1, U2.20 (TX), U5.34 (PA0)
/GPS_WAKEUP: U2.18 (WKUP), U5.2 (PE3)
/HSYNC: U5.96 (PC6), U11.12 (HSYNC)
/IM0: R14.2, U11.6 (IM0)
/IM1: R13.2, U11.7 (IM1)
/IM2: R11.2, U11.8 (IM2)
/IM3: R12.1, U11.9 (IM3)
/IMU_INT: U5.74 (PB13), U7.12 (INT)
/IMU_SCL: U5.100 (PA8), U7.23 (SCL/SCLK)
/IMU_SDA: U5.99 (PC9), U7.24 (SDA/SDI)
/LCD_EN: U5.22 (PF10), U11.14 (DE)
/LCD_RST: U5.102 (PA10), U11.10 (RESET)
/LCD_SDA: U5.21 (PF9), U11.34 (SDI)
/LED1: D1.2 (K), U5.29 (PC3)
/LED2: D2.2 (K), U5.36 (PA2)
/NBL0: U1.15 (LDQM), U5.141 (PE0)
/NBL1: U1.39 (UDQM), U5.142 (PE1)
/NRST: P1.5, U5.25 (NRST)
/OSC32_IN: C6.1, U5.8 (PC14), X1.1
/OSC32_OUT: C7.1, U5.9 (PC15), X1.2
/OSC_EN: U5.27 (PC1), X2.1 (TS)
/OSC_IN: U5.23 (PH0), X2.3 (OUT)
/R2: U5.111 (PC10), U11.20 (DB12)
/R3: U5.46 (PB0), U11.19 (DB13)
/R4: U5.103 (PA11), U11.18 (DB14)
/R5: U5.104 (PA12), U11.17 (DB15)
/R6: U5.47 (PB1), U11.16 (DB16)
/R7: U5.91 (PG6), U11.15 (DB17)
/RDX: U5.81 (PD12), U11.35 (RD)
/SDCKE1: U1.37 (CKE), U5.135 (PB5)
/SDCLK: U1.38 (CLK), U5.93 (PG8)
/SDNCAS: U1.17 (CAS#), U5.132 (PG15)
/SDNE1: U1.19 (CS#), U5.136 (PB6)
/SDNRAS: U1.18 (RAS#), U5.49 (PF11)
/SDNWE: U1.16 (WE#), U5.26 (PC0)
/SW1: R7.1, SW1.4, U5.3 (PE4)
/SW2: R10.1, SW2.4, U5.4 (PE5)
/SWCLK: P1.2, U5.109 (PA14)
/SWDIO: P1.4, U5.105 (PA13)
/SWO: P1.6, U5.133 (PB3)
/TE: U5.80 (PD11), U11.39 (TE)
/USB_DM: CON1.2 (D-), U5.75 (PB14)
/USB_DP: CON1.3 (D+), U5.76 (PB15)
/VSYNC: U5.40 (PA4), U11.11 (VSYNC)
/WRX_DCX: U5.82 (PD13), U11.36 (WRX(D/CX))
/XB_DIN: U4.3 (DIN/~Config/DIO14), U5.113 (PC12)
/XB_DOUT: U4.2 (DOUT/DOP13), U5.116 (PD2)
/XB_RST: U4.5 (~RESET), U5.112 (PC11)
GND: C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.1, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C47.2, C48.2, C50.2, C51.2, C52.2, CON1.5 (GND), L1.1, L2.1, P1.3, P2.1, R2.2, R4.2, R7.2, R10.2, R12.2, R13.1, R15.2, U1.6 (VSSQ), U1.12 (VSSQ), U1.28 (VSS), U1.41 (VSS), U1.46 (VSSQ), U1.52 (VSSQ), U1.54 (VSS), U2.1 (GND), U2.2 (GND), U2.3 (GND), U2.5 (GND), U2.7 (GND), U2.9 (GND), U2.15 (GND), U2.19 (GND), U2.24 (GND), U2.25 (GND), U2.27 (GND), U2.28 (GND), U3.2 (GND), U4.14 (VREF)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
unnamed: R15.1, U9.5
unnamed: C46.2, C49.2, U8.2 (GND)
unnamed: C40.1, U6.2 (CAP)
unnamed: C43.1, U7.10 (REGOUT)
unnamed: D1.1 (A), R8.2
unnamed: D2.1 (A), R9.2
unnamed: L3.1, U3.5 (SW)
unnamed: C37.1, U5.71 (VCAP_1)
unnamed: C41.1, U5.106 (VCAP_2)
unnamed: C32.1, CON1.6 (SHELL1), CON1.7 (SHELL2), CON1.8 (SHELL3), CON1.9 (SHELL4), R4.1
unnamed: R2.1, U2.14 (DR_I2C_CLK)
unnamed: R1.1, U2.13 (DR_I2C_DIO)
VDD: C8.2, C12.1, C14.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C33.1, C34.1, C35.1, C36.1, C38.1, C39.1, C42.1, C45.1, C47.1, C48.1, C49.1, C50.1, C52.1, P1.1, R1.2, R3.1, R8.1, R9.1, R11.1, R14.1, SW1.1, SW2.1, U1.1 (VDD), U1.3 (VDDQ), U1.9 (VDDQ), U1.14 (VDD), U1.27 (VDD), U1.43 (VDDQ), U1.49 (VDDQ), U4.1 (VCC), U5.6 (VBAT), U5.17 (VDD), U5.30 (VDD), U5.32 (VREF+), U5.33 (VDDA), U5.39 (VDD), U5.52 (VDD), U5.62 (VDD), U5.72 (VDD), U5.84 (VDD), U5.95 (VDD), U5.108 (VDD), U5.121 (VDD), U5.131 (VDD), U5.143 (PDR_ON), U5.144 (VDD), U6.1 (VDD), U6.4 (VDDIO), U7.1 (RESV-VDDIO), U7.8 (VDDIO), U7.13 (VDD), U7.22 (~CS), U8.1 (OUT), U10.8 (Vcc), U11.1 (LEDA), U11.40 (VDDI), U11.41 (VDDI), U11.42 (VCI), X2.4 (Vdd)

Notes on the sheet:
SDRAM bus caps
Micro bus caps

Board: 2 copper layers, 74.2 x 58.0 mm, 88 parts (0 on the bottom side), 128 nets.

## Commit log

2014-10-28 Created stm32f429 footprint
    oh god, the pins, they're everywhere
2014-10-28 Added stm32f429 144
2014-10-28 Updated custom library
2014-10-28 added sdram sch
2014-10-28 Initial micro data buses in place
2014-10-28 Schematic done-ish
2014-10-28 Added footprints of barometer and FPC-50
    Also added USB to schematic
2014-10-28 Redid schematic annotation
2014-10-28 made LQFP144
2014-10-29 added mpu9250
2014-10-29 More final schematic, module footprints
    Added all the footprints we need to a library, made a link file from
    part schematics to footprints, everything's ready to be laid out/routed
2014-10-29 Board halfway routed, yay
2014-10-29 Finished routing
2014-10-29 Homogenized silkscreen text size
2014-10-30 fixed silkscreen
2014-10-30 Final ish board
2014-10-30 First revision ordered
2014-11-14 finished rf
2014-11-21 fixed net list and BOM
